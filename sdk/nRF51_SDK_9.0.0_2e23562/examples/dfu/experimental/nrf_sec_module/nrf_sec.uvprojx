# Keil uVision project nrf_sec.uvprojx, settings and files
target nrf51422_xxac (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_ConfidentialDeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf_sec +hex
  c flags: Optim=4 oTime=1 uC99=1 wLevel=2
  c define: __STACK_SIZE=4 __HEAP_SIZE=0
  c misc: --wchar32
  c include: .\;.\ecc;..\..\..\..\components\libraries\util;..\..\..\..\components\libraries\sha256\;..\..\..\..\components\softdevice\s110\headers\;..\..\..\..\components\libraries\bootloader_dfu\experimental
  library: MicroLIB
  memory RVCT4: ROM 0x3dc00 size 0x2400
  memory RVCT9: RAM 0x20007a00 size 0x600
  group main
    ./: SVC_main.c
  group ecc
    ./ecc/: ecc.c
  group sha256
    ../../../../components/libraries/sha256/: sha256.c
  group startup
    ./: system_nrf51.c arm_startup_nrf51.s
software components: CMSIS:CORE 4.1.0
